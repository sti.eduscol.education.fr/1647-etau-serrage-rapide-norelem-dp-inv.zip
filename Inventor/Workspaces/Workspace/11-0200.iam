# Autodesk Inventor assembly: 11-0200
## iProperties
Created: 2007-02
Part Number: 11-0200
Document SubType Name: Assembly
Designer: Gilles GLEMAREC
Author: Gilles GLEMAREC

# Autodesk Inventor part: 000-0000
## iProperties
Created: 2005-09
Part Number: 000-0000
Document SubType Name: Modeling
Project: GB000
Observations: -
Author: GG
Revision Number: 00
